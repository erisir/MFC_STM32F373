# Keil uVision project MFCF373.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F373RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: MFCF373 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, USE_STM32373C_EVAL, STM32F37X
  c include: ..\user;..\stm32f3;..\lib\src;..\lib\inc;..\drive;..\MODBUS\port;..\MODBUS\modbus\include;..\MODBUS\modbus\ascii;..\MODBUS\modbus\functions;..\MODBUS\modbus\rtu;..\MODBUS\modbus\tcp;..\MODBUS\modbus\rtu
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_stm32f37x.s
    ../stm32f3/: system_stm32f37x.c
  group user
    ../stm32f3/: stm32f37x_conf.h stm32f37x_it.c stm32f37x_it.h
    ../prosses/: main.c pid.c readme.txt protocol.c tasks.c protocol.h
    ../MODBUS/modbus/: user_mb_app.c user_mb_app.h
  group drive
    ../drive/: delay.c led.c key.c sdadc.c rs485.c pwm.c timebase.c EEPROM.c spi.c spi.h rs485_DMA.c rs485_DMA.h
  group lib
    ../lib/src/: stm32f37x_gpio.c stm32f37x_rcc.c stm32f37x_usart.c stm32f37x_adc.c stm32f37x_dma.c stm32f37x_sdadc.c stm32f37x_tim.c stm32f37x_misc.c stm32f37x_pwr.c stm32f37x_flash.c stm32f37x_spi.c
  group New Group
    ../MODBUS/modbus/: mb.c
    ../MODBUS/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../MODBUS/modbus/rtu/: mbcrc.c mbrtu.c mbcrc.h mbrtu.h
    ../MODBUS/port/: port.c portevent.c portserial.c porttimer.c
    ../MODBUS/modbus/ascii/: mbascii.c
    ../MODBUS/modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
    ../MODBUS/modbus/tcp/: mbtcp.c mbtcp.h
