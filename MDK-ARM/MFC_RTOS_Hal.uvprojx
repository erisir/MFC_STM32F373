# Keil uVision project MFC_RTOS_Hal.uvprojx, settings and files
target MFC_RTOS_Hal (ARM-ADS)
  device: STM32F373CCTx STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(72000000) FPU2 CPUTYPE("Cortex-M4")
  output: MFC_RTOS_Hal +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F373xC,USE_HAL_DRIVER,STM32F373xC,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include;..\Middlewares\Third_Party\FreeModbus\Drivers\include;..\Middlewares\Third_Party\FreeModbus\Drivers\ascii;..\Middlewares\Third_Party\FreeModbus\Drivers\rtu;..\Middlewares\Third_Party\FreeModbus\Drivers\tcp;..\Middlewares\Third_Party\FreeModbus\User\port;..\Middlewares\Third_Party\FreeModbus\User;..\Middlewares\Third_Party\EEPROM_Emul\Core;..\Middlewares\Third_Party\EEPROM_Emul\Porting\STM32F3
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32f373xc.s
  group Middlewares/FreeModbus
    ../Middlewares/Third_Party/FreeModbus/Drivers/: mb.c
    ../Middlewares/Third_Party/FreeModbus/Drivers/ascii/: mbascii.c
    ../Middlewares/Third_Party/FreeModbus/Drivers/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Middlewares/Third_Party/FreeModbus/Drivers/rtu/: mbcrc.c mbrtu.c
    ../Middlewares/Third_Party/FreeModbus/Drivers/tcp/: mbtcp.c
  group Middlewares/EEPROM
    ../Middlewares/Third_Party/EEPROM_Emul/Core/: eeprom_emul.c
    ../Middlewares/Third_Party/EEPROM_Emul/Porting/STM32F3/: flash_interface.c
  group Application/User/Core
    ../Middlewares/Third_Party/FreeModbus/User/: user_mb_app.c
    ../Middlewares/Third_Party/FreeModbus/User/port/: portserial.c porttimer.c portevent.c
    ../Core/Src/: pwm.c pid.c main.c gpio.c crc.c dma.c freertos.c sdadc.c spi.c tim.c usart.c stm32f3xx_it.c stm32f3xx_hal_msp.c stm32f3xx_hal_timebase_tim.c manager.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_utils.c stm32f3xx_ll_exti.c stm32f3xx_ll_crc.c stm32f3xx_ll_gpio.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_ll_rcc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
